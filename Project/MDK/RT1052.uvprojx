# Keil uVision project RT1052.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: RT1052_emwin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CPU_MIMXRT1052DVL6B,XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1,XIP_BOOT_HEADER_DCD_ENABLE =1,PRINTF_FLOAT_ENABLE=1,SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1,__CC_ARM,ARM_MATH_CM7,__FPU_PRESENT=1
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186,68,111,550
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\drivers;..\..\Libraries\utilities;..\..\Libraries\utilities\io;..\..\Libraries\utilities\log;..\..\Libraries\utilities\str;..\..\User\xip;..\..\User\bsp;..\..\User;..\..\Libraries\hardware;..\..\Libraries\hardware\lcd;..\..\Libraries\hardware\font;..\..\Libraries\hardware\touch;..\..\Libraries\emWin\Config;..\..\Libraries\emWin\demo;..\..\Libraries\emWin\inc;..\..\Libraries\emWin\Include;..\..\Libraries\rtthread\bsp;..\..\Libraries\rtthread\components\finsh;..\..\Libraries\rtthread\include;..\..\Libraries\rtthread\include\libc;..\..\Libraries\rtthread\app;..\..\Libraries\hardware\Gizwits;..\..\Libraries\hardware\Utils;..\..\GUI;..\..\GUI\lvgl;..\..\GUI\lvgl_driver;..\..\GUI_APP;..\..\GUI\lv_examples\lv_apps\demo;..\..\GUI\lv_examples\lv_tests\lv_test_theme;..\..\GUI\lv_examples
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\MIMXRT1052xxxxx_flexspi_nor_sdram.scf
  link misc: --keep=*(.boot_hdr.conf)
--keep=*(.boot_hdr.ivt)
  group CMSIS
    ../../Libraries/: system_MIMXRT1052.c
  group startup
    ./: startup_MIMXRT1052.s
  group drivers
    ../../Libraries/drivers/: fsl_clock.c fsl_gpio.c fsl_lpuart.c fsl_common.c fsl_pit.c fsl_lpi2c.c fsl_pxp.c fsl_elcdif.c fsl_adc.c fsl_gpt.c fsl_adc_etc.c fsl_xbara.c fsl_qtmr.c
  group utilities
    ../../Libraries/utilities/: fsl_assert.c fsl_notifier.c fsl_shell.c fsl_sbrk.c fsl_debug_console.c
    ../../Libraries/utilities/str/: fsl_str.c
    ../../Libraries/utilities/log/: fsl_log.c
    ../../Libraries/utilities/io/: fsl_io.c
  group board
    ../../User/: board.c clock_config.c pin_mux.c
  group hardware
    ../../Libraries/hardware/: pit.c led.c key.c systick.c nvic.c i2c.c adc.c uart.c dht11.c mpu6050.c exit.c bsp_uart.c core_delay.c gpt.c lpi2c.c pump.c pwm.c step.c
    ../../Libraries/hardware/lcd/: bsp_lcd.c
    ../../Libraries/hardware/font/: fonts.c
    ../../Libraries/hardware/touch/: bsp_i2c_touch.c bsp_touch_gtxx.c
    ../../Libraries/hardware/Utils/: common.c dataPointTools.c ringbuffer.c
  group user
    ../../User/: main.c
  group xip
    ../../User/xip/: fire_imxrt1052_sdram_ini_dcd.c fire_imxrt1052_spiflash_config.c fsl_flexspi_nor_boot.c
  group rtthread/app
    ../../Libraries/rtthread/app/: rt_task_temp.c gz_datasend.c rt_task_control.c rt_task_adc.c rt_task_lighting.c rt_task_lvgl.c
  group rtthread/bsp
    ../../Libraries/rtthread/bsp/: rtconfig.h rtboard.c
  group rtthread/components
    ../../Libraries/rtthread/components/finsh/: cmd.c msh.c shell.c
  group rtthread/src
    ../../Libraries/rtthread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group rtthread/lib
    ../../Libraries/rtthread/libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group gizwits
    ../../Libraries/hardware/Gizwits/: gizwits_product.c gizwits_protocol.c
  group lvgl/src
    ../../GUI/lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../../GUI/lvgl/src/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_basic.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rect.c lv_draw_triangle.c lv_img_cache.c lv_img_decoder.c
    ../../GUI/lvgl/src/lv_font/: lv_font.c lv_font_fmt_txt.c lv_font_roboto_12.c lv_font_roboto_16.c lv_font_roboto_22.c lv_font_roboto_28.c lv_font_unscii_8.c
    ../../GUI/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../GUI/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_circ.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_task.c lv_templ.c lv_txt.c lv_utils.c
    ../../GUI/lvgl/src/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_canvas.c lv_cb.c lv_chart.c lv_cont.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_spinbox.c lv_sw.c lv_ta.c lv_table.c lv_tabview.c lv_tileview.c lv_win.c
    ../../GUI/lvgl/src/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
  group lvgl/driver
    ../../GUI/lvgl_driver/: lv_port_disp.c lv_port_indev.c
  group lvgl/draw
    ../../GUI_APP/: lv_draw_home.c lv_draw_ctrl.c lv_draw_main.c lv_draw_about.c lv_draw_setting.c
  group lv_demo
    ../../GUI/lv_examples/lv_apps/demo/: demo.c img_bubble_pattern.c
    ../../GUI/lv_examples/lv_tests/lv_test_theme/: lv_test_theme_1.c lv_test_theme_2.c
